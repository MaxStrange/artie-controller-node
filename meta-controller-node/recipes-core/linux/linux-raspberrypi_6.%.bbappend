FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://docker-fragment.cfg"
