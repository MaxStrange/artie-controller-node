# Add the networkmanager-nmtui package as part of the networkmanager recipe
PACKAGECONFIG:append = " nmtui"
